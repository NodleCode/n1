# Keil uVision project ibeacon.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ibeacon_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;..\src\platform;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_ancc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bass;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bcss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bmss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bond_db;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_common;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_ctsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_ctss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_custs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_default_hnd;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_diss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_easy;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_entry;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_findme;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_gattc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_proxr;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_sec;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_suotar;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_udss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_wsss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\em;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\llc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\lld;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\llm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\ea;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\ea\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\em;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\em\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\hci;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\hci\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\hci\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att\attc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att\attm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att\atts;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gap;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gap\gapc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gap\gapm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gatt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gatt\gattc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gatt\gattm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\l2c;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\l2c\l2cc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\l2c\l2cm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\smp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\smp\smpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\smp\smpm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\basc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\basc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\basc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\bass;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\bass\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\bass\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom\custs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom\custs\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom\custs\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\disc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\disc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\disc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\diss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\diss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\diss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findl\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findl\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findt\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findt\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lans;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lans\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lans\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tips;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tips\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tips\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\rwble;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\rwble_hl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\ldscripts;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\misc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\scatterfiles;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot\ARM;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot\GCC;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler\ARM;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler\GCC;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\ll;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\main;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\arch_console;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\common;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\common\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\crypto;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\dbg;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\dbg\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\gtl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\gtl\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\gtl\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\h4tl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\h4tl\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\ke;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\ke\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\ke\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\nvds;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\nvds\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\nvds\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rf;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rf\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rf\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rwip;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rwip\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rwip\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\adc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\battery;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\ble;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\dma;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\gpio;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\hw_otpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\i2c;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\i2c_eeprom;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\pdm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\reg;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\rtc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\spi;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\spi_flash;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\syscntl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\systick;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\timer;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\trng;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\uart;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\wifi;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\wkupct_quadec;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include\CMSIS;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include\CMSIS\5.6.0;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include\CMSIS\5.6.0\Include;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\include;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\output;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\output\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\output\Keil_5;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\utilities;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\utilities\otp_cs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\utilities\otp_hdr;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\crc32;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\hash;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\irng;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\micro_ecc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\rand;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=ibeacon_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/core_modules/arch_console/: arch_console.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/core_modules/nvds/src/: nvds.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/third_party/rand/: chacha20.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/third_party/hash/: hash.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/system_library/output/Keil_5/: da14531.lib da14585_586.lib
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/utilities/otp_cs/: otp_cs.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/syscntl/: syscntl.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/adc/: adc_531.c adc_58x.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/trng/: trng.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/spi_flash/: spi_flash.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/systick/: systick.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/gpio/: gpio.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/hw_otpc/: hw_otpc_531.c hw_otpc_58x.c
    ../../../SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/driver/uart/: uart.c uart_utils.c
  group sdk_ble
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/ble_stack/rwble/: rwble.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/core_modules/rwip/src/: rwip.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/platform/core_modules/rf/src/: ble_arp.c rf_531.c rf_585.c
  group sdk_profiles
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/ble_stack/profiles/: prf.c
  group sdk_app
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/app_modules/src/app_entry/: app_entry_point.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    E:/Nodle_NanoComputer/SDK_6.0.16.1144/DA145xx_SDK/6.0.16.1144/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: ibeacon.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: ibeacon_586 +hex
  AfterMake: as above
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=ibeacon_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: da14531_ibeacon +hex
  AfterMake: as above
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: ..\src;..\src\config;..\src\platform;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_ancc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bass;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bcss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bmss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_bond_db;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_common;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_ctsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_ctss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_custs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_default_hnd;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_diss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_easy;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_entry;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_findme;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_gattc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_proxr;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_sec;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_suotar;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_udss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\app_modules\src\app_wsss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\em;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\llc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\lld;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\controller\llm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\ea;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\ea\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\em;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\em\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\hci;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\hci\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\hci\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att\attc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att\attm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\att\atts;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gap;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gap\gapc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gap\gapm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gatt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gatt\gattc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\gatt\gattm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\l2c;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\l2c\l2cc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\l2c\l2cm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\smp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\smp\smpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\host\smp\smpm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\anp\anps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\basc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\basc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\basc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\bass;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\bass\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bas\bass\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\blp\blps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom\custs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom\custs\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\custom\custs\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\disc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\disc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\disc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\diss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\diss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\dis\diss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findl\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findl\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findt\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\find\findt\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\glp\glps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lans;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lans\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\lan\lans\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tips;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tips\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\tip\tips\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\uds\udss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\rwble;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\ble_stack\rwble_hl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\ldscripts;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\misc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\scatterfiles;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot\ARM;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot\GCC;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\boot\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler\ARM;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler\GCC;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\compiler\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\ll;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\arch\main;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\arch_console;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\common;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\common\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\crypto;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\dbg;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\dbg\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\gtl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\gtl\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\gtl\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\h4tl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\h4tl\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\ke;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\ke\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\ke\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\nvds;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\nvds\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\nvds\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rf;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rf\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rf\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rwip;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rwip\api;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\core_modules\rwip\src;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\adc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\battery;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\ble;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\dma;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\gpio;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\hw_otpc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\i2c;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\i2c_eeprom;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\pdm;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\reg;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\rtc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\spi;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\spi_flash;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\syscntl;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\systick;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\timer;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\trng;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\uart;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\wifi;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\driver\wkupct_quadec;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include\CMSIS;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include\CMSIS\5.6.0;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\include\CMSIS\5.6.0\Include;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\include;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\output;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\output\IAR;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\system_library\output\Keil_5;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\utilities;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\utilities\otp_cs;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\platform\utilities\otp_hdr;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\crc32;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\hash;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\irng;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\micro_ecc;E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\third_party\rand
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" E:\Nodle_NanoComputer\SDK_6.0.16.1144\DA145xx_SDK\6.0.16.1144\sdk\common_project_files\misc\da14531_symbols.txt  --symdefs=ibeacon_symdef.txt --any_placement=best_fit --datacompressor off
